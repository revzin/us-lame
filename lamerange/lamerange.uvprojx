# Keil uVision project lamerange.uvprojx, settings and files
target 042 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F042F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lamerange_exe
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F042x6
  c include: ..\common\CMSIS\Include;..\common\CMSIS\Device\ST\STM32F0xx\Include;..\lamerange;..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group CMSIS
    ../common/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h
    ../common/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f042x6.s
    ../common/: misc.h misc.c
  group App
    ./: main.c irq_handlers.c test_sandbox.c test_sandbox.h
    ../common/: ownassert.c ownassert.h
  group Board Support
    ./: bsp_clocks.h bsp_clocks.c bsp_power.c bsp_power.h bsp_syscfg.c bsp_syscfg.h bsp_tx.c bsp_tx.h
